# Keil uVision project withcmsis.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: withcmsis
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c io_handler.h io_handler.c MyBitMacros.h io_mapping_v1.h io_pin_definitions.h MyLed.h MyLed.c MyButton.h MyButton.c MyEXTI.h MyEXTI.c MyClock.h MyClock.c MyPWM.c MyPWM.h MyWatchdog.h MyWatchdog.c MySPI.c MySPI.h MyLIS3DSH.h LIS3DSH_REGISTERS.h MyLIS3DSH.c MyDMA.h MyDMA.c
software components: CMSIS:CORE 5.1.1, Device:Startup 2.6.3
